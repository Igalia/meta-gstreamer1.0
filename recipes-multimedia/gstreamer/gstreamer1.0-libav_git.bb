require gstreamer1.0-libav.inc
require gstreamer_git.inc

SRC_URI = "gitsm://gitlab.freedesktop.org/gstreamer/gst-libav.git;protocol=https;branch=master"